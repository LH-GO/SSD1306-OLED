# Keil uVision project OLED.uvproj, settings and files
target OLED (MCS-51)
  device: STC12C5A60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: OLED +hex
  c flags: Optimize=8 SizeSpeed=1
  group MAIN
    ./: main.c oled.c
